/**
 * @file    oled_ssd1306.c
 * @brief   SSD1306 OLED I2C 驱动 — PA0(SDA) + PA1(SCL)
 *
 * I2C0, PF3, 7-bit 地址 0x3C
 * PA0/PA1 是芯片默认 BSL I2C 引脚, 开漏结构, 需外接 4.7kΩ 上拉 (OLED模块自带)
 */

#include "oled_ssd1306.h"
#include "delay.h"
#include "i2c_blocking.h"

#define OLED_ADDR  0x3C

/* --- I2C 硬件初始化 (参考 TI 官方 i2c_controller_rw_multibyte_fifo_poll 示例) --- */
static void oled_i2c_hw_init(void)
{
    DL_GPIO_reset(GPIOA);
    DL_GPIO_enablePower(GPIOA);

    DL_I2C_reset(I2C0_BUS);
    DL_I2C_enablePower(I2C0_BUS);
    delay_cycles(16);  /* POWER_STARTUP_DELAY */

    i2c_initController(I2C0_BUS,
        IOMUX_PINCM1, IOMUX_PINCM1_PF_I2C0_SDA,
        IOMUX_PINCM2, IOMUX_PINCM2_PF_I2C0_SCL,
        7);   /* 400kHz @ 32MHz BUSCLK */
}

/* --- 底层通信 --- */
static void oled_cmd(uint8_t cmd)
{
    uint8_t buf[2] = {0x00, cmd};
    i2c_transmitBlocking(I2C0_BUS, OLED_ADDR, buf, 2);
}

static void oled_set_pos(uint8_t page, uint8_t col)
{
    oled_cmd(0xB0 | (page & 7));
    oled_cmd(0x00 | (col & 0x0F));
    oled_cmd(0x10 | ((col >> 4) & 0x0F));
}

static void oled_data(const uint8_t *data, int len)
{
    uint8_t buf[129];
    int sent = 0;
    while (sent < len) {
        int chunk = (len - sent > 128) ? 128 : (len - sent);
        buf[0] = 0x40;
        for (int i = 0; i < chunk; i++) buf[i + 1] = data[sent + i];
        i2c_transmitBlocking(I2C0_BUS, OLED_ADDR, buf, chunk + 1);
        sent += chunk;
    }
}

/* --- 6x8 ASCII 字体 --- */
static const uint8_t font6x8[][6] = {
    {0x00,0x00,0x00,0x00,0x00,0x00}, {0x00,0x00,0x5F,0x00,0x00,0x00},
    {0x00,0x07,0x00,0x07,0x00,0x00}, {0x14,0x7F,0x14,0x7F,0x14,0x00},
    {0x24,0x2A,0x7F,0x2A,0x12,0x00}, {0x23,0x13,0x08,0x64,0x62,0x00},
    {0x36,0x49,0x55,0x22,0x50,0x00}, {0x00,0x05,0x03,0x00,0x00,0x00},
    {0x00,0x1C,0x22,0x41,0x00,0x00}, {0x00,0x41,0x22,0x1C,0x00,0x00},
    {0x08,0x2A,0x1C,0x2A,0x08,0x00}, {0x08,0x08,0x3E,0x08,0x08,0x00},
    {0x00,0x50,0x30,0x00,0x00,0x00}, {0x08,0x08,0x08,0x08,0x08,0x00},
    {0x00,0x60,0x60,0x00,0x00,0x00}, {0x20,0x10,0x08,0x04,0x02,0x00},
    {0x3E,0x51,0x49,0x45,0x3E,0x00}, {0x00,0x42,0x7F,0x40,0x00,0x00},
    {0x42,0x61,0x51,0x49,0x46,0x00}, {0x21,0x41,0x45,0x4B,0x31,0x00},
    {0x18,0x14,0x12,0x7F,0x10,0x00}, {0x27,0x45,0x45,0x45,0x39,0x00},
    {0x3C,0x4A,0x49,0x49,0x30,0x00}, {0x01,0x71,0x09,0x05,0x03,0x00},
    {0x36,0x49,0x49,0x49,0x36,0x00}, {0x06,0x49,0x49,0x29,0x1E,0x00},
    {0x00,0x36,0x36,0x00,0x00,0x00}, {0x00,0x56,0x36,0x00,0x00,0x00},
    {0x00,0x08,0x14,0x22,0x41,0x00}, {0x14,0x14,0x14,0x14,0x14,0x00},
    {0x41,0x22,0x14,0x08,0x00,0x00}, {0x02,0x01,0x51,0x09,0x06,0x00},
    {0x32,0x49,0x79,0x41,0x3E,0x00}, {0x7E,0x11,0x11,0x11,0x7E,0x00},
    {0x7F,0x49,0x49,0x49,0x36,0x00}, {0x3E,0x41,0x41,0x41,0x22,0x00},
    {0x7F,0x41,0x41,0x22,0x1C,0x00}, {0x7F,0x49,0x49,0x49,0x41,0x00},
    {0x7F,0x09,0x09,0x01,0x01,0x00}, {0x3E,0x41,0x41,0x51,0x32,0x00},
    {0x7F,0x08,0x08,0x08,0x7F,0x00}, {0x00,0x41,0x7F,0x41,0x00,0x00},
    {0x20,0x40,0x41,0x3F,0x01,0x00}, {0x7F,0x08,0x14,0x22,0x41,0x00},
    {0x7F,0x40,0x40,0x40,0x40,0x00}, {0x7F,0x02,0x04,0x02,0x7F,0x00},
    {0x7F,0x04,0x08,0x10,0x7F,0x00}, {0x3E,0x41,0x41,0x41,0x3E,0x00},
    {0x7F,0x09,0x09,0x09,0x06,0x00}, {0x3E,0x41,0x51,0x21,0x5E,0x00},
    {0x7F,0x09,0x19,0x29,0x46,0x00}, {0x46,0x49,0x49,0x49,0x31,0x00},
    {0x01,0x01,0x7F,0x01,0x01,0x00}, {0x3F,0x40,0x40,0x40,0x3F,0x00},
    {0x1F,0x20,0x40,0x20,0x1F,0x00}, {0x7F,0x20,0x18,0x20,0x7F,0x00},
    {0x63,0x14,0x08,0x14,0x63,0x00}, {0x03,0x04,0x78,0x04,0x03,0x00},
    {0x61,0x51,0x49,0x45,0x43,0x00}, {0x00,0x00,0x7F,0x41,0x41,0x00},
    {0x02,0x04,0x08,0x10,0x20,0x00}, {0x41,0x41,0x7F,0x00,0x00,0x00},
    {0x04,0x02,0x01,0x02,0x04,0x00},
};

static void oled_char(uint8_t col, uint8_t page, char c)
{
    if (c < 32 || c > 94) return;
    const uint8_t *glyph = font6x8[c - 32];
    oled_set_pos(page, col);
    uint8_t buf[7]; buf[0] = 0x40;
    for (int i = 0; i < 6; i++) buf[i + 1] = glyph[i];
    i2c_transmitBlocking(I2C0_BUS, OLED_ADDR, buf, 7);
}

/* --- 公开 API --- */
void oled_init(void)
{
    oled_i2c_hw_init();
    delay_ms(50);

    uint8_t cmds[] = {
        0xAE, 0x20,0x00, 0x40, 0xA1, 0xC8, 0xDA,0x12,
        0x81,0x7F, 0xA4, 0xA6, 0xD9,0xF1, 0xDB,0x40,
        0x8D,0x14, 0x2E, 0xAF,
    };
    for (uint32_t i = 0; i < sizeof(cmds); i++) oled_cmd(cmds[i]);
    delay_ms(10);
}

void oled_clear(void)
{
    uint8_t zero[128] = {0};
    for (int pg = 0; pg < 8; pg++) { oled_set_pos(pg, 0); oled_data(zero, 128); }
}

void oled_chess(void)
{
    uint8_t row[128];
    for (int pg = 0; pg < 8; pg++) {
        for (int i = 0; i < 128; i++) row[i] = ((i/8+pg)%2) ? 0xFF : 0x00;
        oled_set_pos(pg, 0); oled_data(row, 128);
    }
}

void oled_text(uint8_t col, uint8_t page, const char *str)
{
    while (*str) { oled_char(col, page, *str); col += 6; str++; }
}
